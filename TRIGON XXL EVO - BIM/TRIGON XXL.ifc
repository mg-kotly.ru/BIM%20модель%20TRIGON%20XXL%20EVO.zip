Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcEnergyConversionDevice: XXL EVO 900, BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000:XXL EVO 900:683168
Type - Прочее - Категория: Оборудование; Имя семейства: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000; Макс. температура дымовых газов при 80⁄60 oС: 69 kg/K/s3; Максимальный объемный расход конденсата: 56.1 Л/ч; Максимальный остаточный напор дымовых газов после котла: 150 Pa; Максимальный уровень CO: 4 мг⁄кВт∙ч; Максимальный уровень N⁰x: 37 мг⁄кВт∙ч; Массовый расход дымовых газов макс: 1407 кг/ч; Массовый расход дымовых газов мин: 427 кг/ч; Объемный расход дымовых газов макс: 0.37 m3/s; Объемный расход дымовых газов мин: 0.109167 m3/s
Type - Размеры - Горелка 1: yes; Горелка 2: no; Соединитель 1: yes; Соединитель 1 Длина: 0 mm; Соединитель 2: no; ADSK_Размер_Высота: 1555 mm; ADSK_Размер_Глубина: 2565 mm; ADSK_Размер_Ширина: 1170 mm; B1: 1075 mm; B2: 585 mm; B3: 95 mm; B4: 960 mm; B5: 100 mm; B6: 980 mm; D: 350 mm; G: 60 mm; H1: 1110 mm; H2: 660 mm; H3: 530 mm; H4: 480 mm; L1: 480 mm; L2: 1030 mm; L3: 260 mm; L4: 110 mm; L5: 550 mm; LW: 185 mm; W: 89 mm; Высота G: 480 mm; Высота W: 660 mm; Высота дымовых газов: 530 mm; Высота слива: 272 mm; Глубина блока: 2085 mm; Диаметр компенсатора: 200 mm; Длина 1_1: 678.5 mm; Длина 1_2: 674 mm; Длина 1_3: 1 mm; Длина 2_1: 968 mm; Длина 2_2: 1 mm; Длина 2_3: 1 mm; Длина 3_1: 1933 mm; Длина 3_2: 1 mm; Длина отрезка: 325 mm; Подключение воды: 80 mm; Подключение газа: 50 mm; Подключение дымохода: 350 mm; Подключение забора воздуха_для внешнего забора: 355 mm; Подключение слива конденсата: 40 mm; Радиус компенсатора: 102 mm; Служебный размер: 18 mm; Смещение: 94 mm; Смещение ножек: 1124 mm; Смещение соединения воды: 1225 mm; Соединитель 2 Длина: 480 mm; Углубление: 10 mm; Ширина G: 100 mm; Ширина W: 1075 mm; Ширина дымовых газов: 260 mm; Ширина полки Горелки: 697.4 mm; Ширина слива: 645 mm
Type - Силы - Уровень звуковой мощности: 68.7 дБ(А)
Type - Текст - ADSK_Масса: 1468
Type - Электросети - Класс защиты от поражения электрическим током: IP00; Потребляемая котлом электрическая мощность макс: 1270 W; Потребляемая котлом электрическая мощность мин: 320 W; Предохранитель: 16 A; Частота: 50 Hz
Type - Электросети - Нагрузки - ADSK_Количество фаз: 1; ADSK_Напряжение: 400 V
Видимость - Зона обслуживания: no; Контрфланец: no
Зависимости - Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Идентификация - Марка: 49
Механизмы - ELCO_Слив: 0; ADSK_Расход воздуха приточный: 0 m3/s; ADSK_Расход жидкости: 0 m3/s; ELCO_Отвод домовых газов: 0 m3/s; ELCO_Расход газа: 0 m3/s; Классификация систем: Приточный воздух,Мощность,Не определено,Обратная жидкость,Приточная жидкость,Канализация,Отработанный воздух
Прочее - Код типа: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000: XXL EVO 900; Семейство: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000: XXL EVO 900; Семейство и типоразмер: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000: XXL EVO 900; Тип: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000: XXL EVO 900
Размеры - Смещение водяного соединителя: 0 mm; Объем: 3.50028 m3; Смещение фланца: 45 mm
Стадии - Стадия возведения: Стадия 1
