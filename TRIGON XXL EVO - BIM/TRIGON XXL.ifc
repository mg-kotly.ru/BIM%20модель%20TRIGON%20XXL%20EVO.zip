Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-29T01:34:28
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181011_1545(x64) - Exporter 17.0.511.0 - Альтернативный интерфейс 17.14.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Sep 29 01:34:28 2020 * Host: 189-i7-2600k * Database: C:\Users\EAD1D~1.PID\AppData\Local\Temp\{4B78CE5C-EBF0-4ED8-A500-9C4DE8160D0D}\ifc * Database version: 5507 * Database creation date: Tue Sep 29 01:34:22 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Sep 29 01:34:23 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Sep 29 01:34:23 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuilding
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Размеры - Расчетная высота: 0 mm

# IfcEnergyConversionDevice: XXL EVO 1000, BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000:XXL EVO 1000:683176
In: Этаж 01
Type - PredefinedType: WATER; Material: Color RGB 120-120-120, Color RGB 216-216-216, Color RGB 181-181-181, Color RGB 255-255-240, Color RGB 100-100-100, Color RGB 049-049-049
Type - Видимость - Газ_Фланец: yes
Type - Графика - Зона обслуживания_Глубина_Задняя часть: 450 mm; Зона обслуживания_Глубина_Левая сторона: 800 mm; Зона обслуживания_Глубина_Лицевая часть: 1000 mm; Зона обслуживания_Глубина_Правая сторона: 450 mm; Привязка_Зона обслуживания_Задняя часть: 550 mm
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: ELCO; ADSK_Код изделия: 3581769; ADSK_Марка: TRIGON XXL EVO 1000; ADSK_Наименование: Водотрубный премиксный конденсационный котел TRIGON XXL EVO, 945 кВт, максимальное давление 8 Бар; ELCO_Страна производства: Нидерланды
Type - Идентификация - ADSK_URL документации изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_URL страницы изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.pro/manufacturer/company/16987; BL_Email: support@ru.elco.net; BL_Разработано: support@bimlib.pro; URL: https://elco.net.ru/; Заголовок OmniClass: Hot Water Heat Generators; Изготовитель: ELCO Heating Solutions; Имя типа: XXL EVO 1000; Номер OmniClass: 23.75.10.11.14; Описание: Высокоэффективные водотрубные премиксные котлы TRIGON XXL с уникальной модулируемой водоохлаждаемой горелкой. TRIGON XXL EVO – высокоэффективные конденсационные котлы с эффективностью до 109,7 %
Type - Механизмы - Гидравлическое сопротивление при номинальном расходе ΔT=20: 67000 Pa; Давление воды макс: 800000 Pa; Давление воды мин: 150000 Pa; Максимальная рабочая температура: 90 kg/K/s3; Максимальная разница температур между подающей и обратной линией: 30 kg/K/s3; Номинальный расход при ΔT=20: 0.0113889 m3/s; Объем воды: 0.11 m3
Type - Механизмы - Нагрузки - Минимальная тепловая мощность при 50⁄30 ⁰С: 298000 W; Минимальная тепловая мощность при 80⁄60 ⁰С: 269000 W; Номинальная тепловая мощность при 50⁄30 ⁰С: 1001000 W; Номинальная тепловая мощность при 80⁄60 ⁰С: 945000 W; Номинальная тепловая нагрузка макс: 966000 W; Номинальная тепловая нагрузка мин: 276000 W; Эффективность на макс при 50⁄30 ⁰С: 1.036; Эффективность на макс при 80⁄60 ⁰С: 0.978; Эффективность на мин при 50⁄30 ⁰С: 1.082; Эффективность на мин при 80⁄60 ⁰С: 0.974
Type - Механизмы - Расход - Максимальное давление газа: 10000 Pa; Максимальный расход газа: 0.0288408 m3/s; Минимальное давление природного газа G20: 1700 Pa; Минимальное давление природного газа G25: 2000 Pa; Минимальное давление СУГ G31: 3000 Pa; Минимальный расход газа: 0.00824023 m3/s; Номинальное давление природного газа G20: 2000 Pa; Номинальное давление природного газа G25: 2500 Pa; Номинальное давление СУГ G31: 3000 Pa; Фактическая калорийность газа: 8000
Type - Прочее - Категория: Оборудование; Имя семейства: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000; Макс. температура дымовых газов при 80⁄60 oС: 69 kg/K/s3; Максимальный объемный расход конденсата: 62,7 Л/ч; Максимальный остаточный напор дымовых газов после котла: 150 Pa; Максимальный уровень CO: 4 мг⁄кВт∙ч; Максимальный уровень N⁰x: 37 мг⁄кВт∙ч; Массовый расход дымовых газов макс: 1572 кг/ч; Массовый расход дымовых газов мин: 478 кг/ч; Объемный расход дымовых газов макс: 0.413056 m3/s; Объемный расход дымовых газов мин: 0.121944 m3/s
Type - Размеры - Горелка 1: yes; Горелка 2: no; Соединитель 1: yes; Соединитель 1 Длина: 0 mm; Соединитель 2: no; ADSK_Размер_Высота: 1555 mm; ADSK_Размер_Глубина: 2565 mm; ADSK_Размер_Ширина: 1370 mm; B1: 1225 mm; B2: 685 mm; B3: 145 mm; B4: 1160 mm; B5: 150 mm; B6: 1080 mm; D: 400 mm; G: 76 mm; H1: 1110 mm; H2: 660 mm; H3: 530 mm; H4: 480 mm; L1: 480 mm; L2: 1030 mm; L3: 260 mm; L4: 100 mm; L5: 550 mm; LW: 185 mm; W: 89 mm; Высота G: 480 mm; Высота W: 660 mm; Высота дымовых газов: 530 mm; Высота слива: 272 mm; Глубина блока: 2085 mm; Диаметр компенсатора: 250 mm; Длина 1_1: 678.5 mm; Длина 1_2: 674 mm; Длина 1_3: 1 mm; Длина 2_1: 968 mm; Длина 2_2: 1 mm; Длина 2_3: 1 mm; Длина 3_1: 1933 mm; Длина 3_2: 1 mm; Длина отрезка: 325 mm; Подключение воды: 80 mm; Подключение газа: 65 mm; Подключение дымохода: 400 mm; Подключение забора воздуха_для внешнего забора: 355 mm; Подключение слива конденсата: 40 mm; Радиус компенсатора: 127 mm; Служебный размер: 18 mm; Смещение: 94 mm; Смещение ножек: 1324 mm; Смещение соединения воды: 1225 mm; Соединитель 2 Длина: 480 mm; Углубление: 10 mm; Ширина G: 150 mm; Ширина W: 1225 mm; Ширина дымовых газов: 260 mm; Ширина полки Горелки: 778.5 mm; Ширина слива: 645 mm
Type - Силы - Уровень звуковой мощности: 68.7 дБ(А)
Type - Текст - ADSK_Масса: 1634
Type - Электросети - Класс защиты от поражения электрическим током: IP00; Потребляемая котлом электрическая мощность макс: 1270 W; Потребляемая котлом электрическая мощность мин: 320 W; Предохранитель: 16 A; Частота: 50 Hz
Type - Электросети - Нагрузки - ADSK_Количество фаз: 1; ADSK_Напряжение: 400 V
Видимость - Зона обслуживания: no; Контрфланец: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 50
Механизмы - ELCO_Слив: 0; ADSK_Расход воздуха приточный: 0 m3/s; ADSK_Расход жидкости: 0 m3/s; ELCO_Отвод домовых газов: 0 m3/s; ELCO_Расход газа: 0 m3/s; Классификация систем: Приточный воздух,Мощность,Не определено,Обратная жидкость,Приточная жидкость,Канализация,Отработанный воздух
Прочее - Код типа: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000: XXL EVO 1000; Семейство: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000: XXL EVO 1000; Семейство и типоразмер: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000: XXL EVO 1000; Тип: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000: XXL EVO 1000
Размеры - Смещение водяного соединителя: 0 mm; Объем: 4.07963 m3; Смещение фланца: 45 mm
Стадии - Стадия возведения: Стадия 1

# IfcEnergyConversionDevice: XXL EVO 1100, BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000:XXL EVO 1100:683190
In: Этаж 01
Type - PredefinedType: WATER; Material: Color RGB 120-120-120, Color RGB 216-216-216, Color RGB 181-181-181, Color RGB 255-255-240, Color RGB 100-100-100, Color RGB 049-049-049
Type - Видимость - Газ_Фланец: yes
Type - Графика - Зона обслуживания_Глубина_Задняя часть: 450 mm; Зона обслуживания_Глубина_Левая сторона: 800 mm; Зона обслуживания_Глубина_Лицевая часть: 1000 mm; Зона обслуживания_Глубина_Правая сторона: 450 mm; Привязка_Зона обслуживания_Задняя часть: 550 mm
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: ELCO; ADSK_Код изделия: 3581770; ADSK_Марка: TRIGON XXL EVO 1100; ADSK_Наименование: Водотрубный премиксный конденсационный котел TRIGON XXL EVO, 1043 кВт, максимальное давление 8 Бар; ELCO_Страна производства: Нидерланды
Type - Идентификация - ADSK_URL документации изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_URL страницы изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.pro/manufacturer/company/16987; BL_Email: support@ru.elco.net; BL_Разработано: support@bimlib.pro; URL: https://elco.net.ru/; Заголовок OmniClass: Hot Water Heat Generators; Изготовитель: ELCO Heating Solutions; Имя типа: XXL EVO 1100; Номер OmniClass: 23.75.10.11.14; Описание: Высокоэффективные водотрубные премиксные котлы TRIGON XXL с уникальной модулируемой водоохлаждаемой горелкой. TRIGON XXL EVO – высокоэффективные конденсационные котлы с эффективностью до 109,7 %
Type - Механизмы - Гидравлическое сопротивление при номинальном расходе ΔT=20: 83000 Pa; Давление воды макс: 800000 Pa; Давление воды мин: 150000 Pa; Максимальная рабочая температура: 90 kg/K/s3; Максимальная разница температур между подающей и обратной линией: 30 kg/K/s3; Номинальный расход при ΔT=20: 0.0125 m3/s; Объем воды: 0.117 m3
Type - Механизмы - Нагрузки - Минимальная тепловая мощность при 50⁄30 ⁰С: 330000 W; Минимальная тепловая мощность при 80⁄60 ⁰С: 297000 W; Номинальная тепловая мощность при 50⁄30 ⁰С: 1104000 W; Номинальная тепловая мощность при 80⁄60 ⁰С: 1043000 W; Номинальная тепловая нагрузка макс: 1066000 W; Номинальная тепловая нагрузка мин: 305000 W; Эффективность на макс при 50⁄30 ⁰С: 1.036; Эффективность на макс при 80⁄60 ⁰С: 0.978; Эффективность на мин при 50⁄30 ⁰С: 1.082; Эффективность на мин при 80⁄60 ⁰С: 0.974
Type - Механизмы - Расход - Максимальное давление газа: 10000 Pa; Максимальный расход газа: 0.0318264 m3/s; Минимальное давление природного газа G20: 1700 Pa; Минимальное давление природного газа G25: 2000 Pa; Минимальное давление СУГ G31: 3000 Pa; Минимальный расход газа: 0.00910605 m3/s; Номинальное давление природного газа G20: 2000 Pa; Номинальное давление природного газа G25: 2500 Pa; Номинальное давление СУГ G31: 3000 Pa; Фактическая калорийность газа: 8000
Type - Прочее - Категория: Оборудование; Имя семейства: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000; Макс. температура дымовых газов при 80⁄60 oС: 69 kg/K/s3; Максимальный объемный расход конденсата: 69.1 Л/ч; Максимальный остаточный напор дымовых газов после котла: 150 Pa; Максимальный уровень CO: 4 мг⁄кВт∙ч; Максимальный уровень N⁰x: 37 мг⁄кВт∙ч; Массовый расход дымовых газов макс: 1734 кг/ч; Массовый расход дымовых газов мин: 528 кг/ч; Объемный расход дымовых газов макс: 0.455833 m3/s; Объемный расход дымовых газов мин: 0.134722 m3/s
Type - Размеры - Горелка 1: yes; Горелка 2: no; Соединитель 1: yes; Соединитель 1 Длина: 0 mm; Соединитель 2: no; ADSK_Размер_Высота: 1555 mm; ADSK_Размер_Глубина: 2565 mm; ADSK_Размер_Ширина: 1370 mm; B1: 1275 mm; B2: 685 mm; B3: 95 mm; B4: 1160 mm; B5: 100 mm; B6: 1180 mm; D: 400 mm; G: 76 mm; H1: 1110 mm; H2: 660 mm; H3: 530 mm; H4: 480 mm; L1: 480 mm; L2: 1030 mm; L3: 260 mm; L4: 100 mm; L5: 550 mm; LW: 185 mm; W: 89 mm; Высота G: 480 mm; Высота W: 660 mm; Высота дымовых газов: 530 mm; Высота слива: 272 mm; Глубина блока: 2085 mm; Диаметр компенсатора: 250 mm; Длина 1_1: 678.5 mm; Длина 1_2: 674 mm; Длина 1_3: 1 mm; Длина 2_1: 968 mm; Длина 2_2: 1 mm; Длина 2_3: 1 mm; Длина 3_1: 1933 mm; Длина 3_2: 1 mm; Длина отрезка: 325 mm; Подключение воды: 80 mm; Подключение газа: 65 mm; Подключение дымохода: 400 mm; Подключение забора воздуха_для внешнего забора: 355 mm; Подключение слива конденсата: 40 mm; Радиус компенсатора: 127 mm; Служебный размер: 18 mm; Смещение: 94 mm; Смещение ножек: 1324 mm; Смещение соединения воды: 1225 mm; Соединитель 2 Длина: 480 mm; Углубление: 10 mm; Ширина G: 100 mm; Ширина W: 1275 mm; Ширина дымовых газов: 260 mm; Ширина полки Горелки: 859.4 mm; Ширина слива: 645 mm
Type - Силы - Уровень звуковой мощности: 68.7 дБ(А)
Type - Текст - ADSK_Масса: 1800
Type - Электросети - Класс защиты от поражения электрическим током: IP00; Потребляемая котлом электрическая мощность макс: 1270 W; Потребляемая котлом электрическая мощность мин: 320 W; Предохранитель: 16 A; Частота: 50 Hz
Type - Электросети - Нагрузки - ADSK_Количество фаз: 1; ADSK_Напряжение: 400 V
Видимость - Зона обслуживания: no; Контрфланец: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 51
Механизмы - ELCO_Слив: 0; ADSK_Расход воздуха приточный: 0 m3/s; ADSK_Расход жидкости: 0 m3/s; ELCO_Отвод домовых газов: 0 m3/s; ELCO_Расход газа: 0 m3/s; Классификация систем: Приточный воздух,Мощность,Не определено,Обратная жидкость,Приточная жидкость,Канализация,Отработанный воздух
Прочее - Код типа: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000: XXL EVO 1100; Семейство: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000: XXL EVO 1100; Семейство и типоразмер: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000: XXL EVO 1100; Тип: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000: XXL EVO 1100
Размеры - Смещение водяного соединителя: 0 mm; Объем: 4.08732 m3; Смещение фланца: 45 mm
Стадии - Стадия возведения: Стадия 1

# IfcEnergyConversionDevice: XXL EVO 1200, BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000:XXL EVO 1200:683198
In: Этаж 01
Type - PredefinedType: WATER; Material: Color RGB 120-120-120, Color RGB 216-216-216, Color RGB 181-181-181, Color RGB 255-255-240, Color RGB 100-100-100, Color RGB 049-049-049
Type - Видимость - Газ_Фланец: yes
Type - Графика - Зона обслуживания_Глубина_Задняя часть: 450 mm; Зона обслуживания_Глубина_Левая сторона: 800 mm; Зона обслуживания_Глубина_Лицевая часть: 1000 mm; Зона обслуживания_Глубина_Правая сторона: 450 mm; Привязка_Зона обслуживания_Задняя часть: 710 mm
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: ELCO; ADSK_Код изделия: 3581771; ADSK_Марка: TRIGON XXL EVO 1200; ADSK_Наименование: Водотрубный премиксный конденсационный котел TRIGON XXL EVO, 1141 кВт, максимальное давление 8 Бар; ELCO_Страна производства: Нидерланды
Type - Идентификация - ADSK_URL документации изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_URL страницы изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.pro/manufacturer/company/16987; BL_Email: support@ru.elco.net; BL_Разработано: support@bimlib.pro; URL: https://elco.net.ru/; Заголовок OmniClass: Hot Water Heat Generators; Изготовитель: ELCO Heating Solutions; Имя типа: XXL EVO 1200; Номер OmniClass: 23.75.10.11.14; Описание: Высокоэффективные водотрубные премиксные котлы TRIGON XXL с уникальной модулируемой водоохлаждаемой горелкой. TRIGON XXL EVO – высокоэффективные конденсационные котлы с эффективностью до 109,7 %
Type - Механизмы - Гидравлическое сопротивление при номинальном расходе ΔT=20: 92000 Pa; Давление воды макс: 800000 Pa; Давление воды мин: 150000 Pa; Максимальная рабочая температура: 90 kg/K/s3; Максимальная разница температур между подающей и обратной линией: 30 kg/K/s3; Номинальный расход при ΔT=20: 0.0136111 m3/s; Объем воды: 0.131 m3
Type - Механизмы - Нагрузки - Минимальная тепловая мощность при 50⁄30 ⁰С: 360000 W; Минимальная тепловая мощность при 80⁄60 ⁰С: 324000 W; Номинальная тепловая мощность при 50⁄30 ⁰С: 1208000 W; Номинальная тепловая мощность при 80⁄60 ⁰С: 1411000 W; Номинальная тепловая нагрузка макс: 1166000 W; Номинальная тепловая нагрузка мин: 333000 W; Эффективность на макс при 50⁄30 ⁰С: 1.036; Эффективность на макс при 80⁄60 ⁰С: 0.978; Эффективность на мин при 50⁄30 ⁰С: 1.082; Эффективность на мин при 80⁄60 ⁰С: 0.974
Type - Механизмы - Расход - Максимальное давление газа: 10000 Pa; Максимальный расход газа: 0.034812 m3/s; Минимальное давление природного газа G20: 3500 Pa; Минимальное давление природного газа G25: 3500 Pa; Минимальное давление СУГ G31: 5000 Pa; Минимальный расход газа: 0.00994202 m3/s; Номинальное давление природного газа G20: 3500 Pa; Номинальное давление природного газа G25: 3500 Pa; Номинальное давление СУГ G31: 5000 Pa; Фактическая калорийность газа: 8000
Type - Прочее - Категория: Оборудование; Имя семейства: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000; Макс. температура дымовых газов при 80⁄60 oС: 69 kg/K/s3; Максимальный объемный расход конденсата: 75.6 Л/ч; Максимальный остаточный напор дымовых газов после котла: 150 Pa; Максимальный уровень CO: 4 мг⁄кВт∙ч; Максимальный уровень N⁰x: 37 мг⁄кВт∙ч; Массовый расход дымовых газов макс: 1897 кг/ч; Массовый расход дымовых газов мин: 576 кг/ч; Объемный расход дымовых газов макс: 0.498611 m3/s; Объемный расход дымовых газов мин: 0.146944 m3/s
Type - Размеры - Соединитель 1: yes; Соединитель 1 Длина: 0 mm; Соединитель 2: no; ADSK_Размер_Высота: 1555 mm; ADSK_Размер_Глубина: 2795 mm; ADSK_Размер_Ширина: 1570 mm; B1: 1425 mm; B2: 785 mm; B3: 145 mm; B4: 1360 mm; B5: 150 mm; B6: 1280 mm; D: 450 mm; G: 76 mm; H1: 1045 mm; H2: 595 mm; H3: 470 mm; H4: 395 mm; L1: 480 mm; L2: 1030 mm; L3: 350 mm; L4: 230 mm; L5: 710 mm; LW: 185 mm; W: 89 mm; Высота G: 395 mm; Высота W: 595 mm; Высота дымовых газов: 470 mm; Высота слива: 161 mm; Глубина блока: 2085 mm; Горелка 1: no; Горелка 2: yes; Диаметр компенсатора: 270 mm; Длина 1_1: 678.5 mm; Длина 1_2: 674 mm; Длина 1_3: 1 mm; Длина 2_1: 968 mm; Длина 2_2: 1 mm; Длина 2_3: 1 mm; Длина 3_1: 1933 mm; Длина 3_2: 1 mm; Длина отрезка: 325 mm; Подключение воды: 80 mm; Подключение газа: 65 mm; Подключение дымохода: 450 mm; Подключение забора воздуха_для внешнего забора: 450 mm; Подключение слива конденсата: 40 mm; Радиус компенсатора: 137 mm; Служебный размер: 18 mm; Смещение: 94 mm; Смещение ножек: 1524 mm; Смещение соединения воды: 1225 mm; Соединитель 2 Длина: 480 mm; Углубление: 10 mm; Ширина G: 150 mm; Ширина W: 1425 mm; Ширина дымовых газов: 350 mm; Ширина полки Горелки: 945.4 mm; Ширина слива: 105 mm
Type - Силы - Уровень звуковой мощности: 68.7 дБ(А)
Type - Текст - ADSK_Масса: 1900
Type - Электросети - Класс защиты от поражения электрическим током: IP00; Потребляемая котлом электрическая мощность макс: 2330 W; Потребляемая котлом электрическая мощность мин: 585 W; Предохранитель: 16 A; Частота: 50 Hz
Type - Электросети - Нагрузки - ADSK_Количество фаз: 1; ADSK_Напряжение: 400 V
Видимость - Зона обслуживания: no; Контрфланец: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 52
Механизмы - ELCO_Слив: 0; ADSK_Расход воздуха приточный: 0 m3/s; ADSK_Расход жидкости: 0 m3/s; ELCO_Отвод домовых газов: 0 m3/s; ELCO_Расход газа: 0 m3/s; Классификация систем: Приточный воздух,Мощность,Не определено,Обратная жидкость,Приточная жидкость,Канализация,Отработанный воздух
Прочее - Код типа: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000: XXL EVO 1200; Семейство: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000: XXL EVO 1200; Семейство и типоразмер: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000: XXL EVO 1200; Тип: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000: XXL EVO 1200
Размеры - Смещение водяного соединителя: 0 mm; Объем: 4.69934 m3; Смещение фланца: 45 mm
Стадии - Стадия возведения: Стадия 1

# IfcEnergyConversionDevice: XXL EVO 1400, BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000:XXL EVO 1400:683206
In: Этаж 01
Type - PredefinedType: WATER; Material: Color RGB 120-120-120, Color RGB 216-216-216, Color RGB 181-181-181, Color RGB 255-255-240, Color RGB 100-100-100, Color RGB 049-049-049
Type - Видимость - Газ_Фланец: yes
Type - Графика - Зона обслуживания_Глубина_Задняя часть: 450 mm; Зона обслуживания_Глубина_Левая сторона: 800 mm; Зона обслуживания_Глубина_Лицевая часть: 1000 mm; Зона обслуживания_Глубина_Правая сторона: 450 mm; Привязка_Зона обслуживания_Задняя часть: 710 mm
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: ELCO; ADSK_Код изделия: 3581772; ADSK_Марка: TRIGON XXL EVO 1400; ADSK_Наименование: Водотрубный премиксный конденсационный котел TRIGON XXL EVO, 1304 кВт, максимальное давление 8 Бар; ELCO_Страна производства: Нидерланды
Type - Идентификация - ADSK_URL документации изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_URL страницы изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.pro/manufacturer/company/16987; BL_Email: support@ru.elco.net; BL_Разработано: support@bimlib.pro; URL: https://elco.net.ru/; Заголовок OmniClass: Hot Water Heat Generators; Изготовитель: ELCO Heating Solutions; Имя типа: XXL EVO 1400; Номер OmniClass: 23.75.10.11.14; Описание: Высокоэффективные водотрубные премиксные котлы TRIGON XXL с уникальной модулируемой водоохлаждаемой горелкой. TRIGON XXL EVO – высокоэффективные конденсационные котлы с эффективностью до 109,7 %
Type - Механизмы - Гидравлическое сопротивление при номинальном расходе ΔT=20: 83000 Pa; Давление воды макс: 800000 Pa; Давление воды мин: 150000 Pa; Максимальная рабочая температура: 90 kg/K/s3; Максимальная разница температур между подающей и обратной линией: 30 kg/K/s3; Номинальный расход при ΔT=20: 0.0155556 m3/s; Объем воды: 0.147 m3
Type - Механизмы - Нагрузки - Минимальная тепловая мощность при 50⁄30 ⁰С: 412000 W; Минимальная тепловая мощность при 80⁄60 ⁰С: 371000 W; Номинальная тепловая мощность при 50⁄30 ⁰С: 1381000 W; Номинальная тепловая мощность при 80⁄60 ⁰С: 1304000 W; Номинальная тепловая нагрузка макс: 1333000 W; Номинальная тепловая нагрузка мин: 381000 W; Эффективность на макс при 50⁄30 ⁰С: 1.036; Эффективность на макс при 80⁄60 ⁰С: 0.978; Эффективность на мин при 50⁄30 ⁰С: 1.082; Эффективность на мин при 80⁄60 ⁰С: 0.974
Type - Механизмы - Расход - Максимальное давление газа: 10000 Pa; Максимальный расход газа: 0.0397979 m3/s; Минимальное давление природного газа G20: 3500 Pa; Минимальное давление природного газа G25: 3500 Pa; Минимальное давление СУГ G31: 5000 Pa; Минимальный расход газа: 0.0113751 m3/s; Номинальное давление природного газа G20: 3500 Pa; Номинальное давление природного газа G25: 3500 Pa; Номинальное давление СУГ G31: 5000 Pa; Фактическая калорийность газа: 8000
Type - Прочее - Категория: Оборудование; Имя семейства: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000; Макс. температура дымовых газов при 80⁄60 oС: 69 kg/K/s3; Максимальный объемный расход конденсата: 86.5 Л/ч; Максимальный остаточный напор дымовых газов после котла: 150 Pa; Максимальный уровень CO: 4 мг⁄кВт∙ч; Максимальный уровень N⁰x: 37 мг⁄кВт∙ч; Массовый расход дымовых газов макс: 2169 кг/ч; Массовый расход дымовых газов мин: 659 кг/ч; Объемный расход дымовых газов макс: 0.57 m3/s; Объемный расход дымовых газов мин: 0.168056 m3/s
Type - Размеры - Соединитель 1: yes; Соединитель 1 Длина: 0 mm; Соединитель 2: no; Горелка 1: no; Горелка 2: yes; ADSK_Размер_Высота: 1575 mm; ADSK_Размер_Глубина: 3310 mm; ADSK_Размер_Ширина: 1370 mm; B1: 1225 mm; B2: 685 mm; B3: 145 mm; B4: 1160 mm; B5: 140 mm; B6: 1080 mm; D: 450 mm; G: 76 mm; H1: 1065 mm; H2: 615 mm; H3: 490 mm; H4: 415 mm; L1: 480 mm; L2: 1550 mm; L3: 350 mm; L4: 165 mm; L5: 710 mm; LW: 185 mm; W: 89 mm; Высота G: 415 mm; Высота W: 615 mm; Высота дымовых газов: 490 mm; Высота слива: 161 mm; Глубина блока: 2600 mm; Диаметр компенсатора: 270 mm; Длина 1_1: 512 mm; Длина 1_2: 679.5 mm; Длина 1_3: 679.5 mm; Длина 2_1: 512 mm; Длина 2_2: 968 mm; Длина 2_3: 1 mm; Длина 3_1: 2448 mm; Длина 3_2: 1 mm; Длина отрезка: 325 mm; Подключение воды: 80 mm; Подключение газа: 65 mm; Подключение дымохода: 450 mm; Подключение забора воздуха_для внешнего забора: 450 mm; Подключение слива конденсата: 40 mm; Радиус компенсатора: 137 mm; Служебный размер: 18 mm; Смещение: 94 mm; Смещение ножек: 1324 mm; Смещение соединения воды: 1225 mm; Соединитель 2 Длина: 480 mm; Углубление: 10 mm; Ширина G: 140 mm; Ширина W: 1225 mm; Ширина дымовых газов: 350 mm; Ширина полки Горелки: 769.9 mm; Ширина слива: 105 mm
Type - Силы - Уровень звуковой мощности: 68.7 дБ(А)
Type - Текст - ADSK_Масса: 2000
Type - Электросети - Класс защиты от поражения электрическим током: IP00; Потребляемая котлом электрическая мощность макс: 2330 W; Потребляемая котлом электрическая мощность мин: 585 W; Предохранитель: 16 A; Частота: 50 Hz
Type - Электросети - Нагрузки - ADSK_Количество фаз: 1; ADSK_Напряжение: 400 V
Видимость - Зона обслуживания: no; Контрфланец: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 53
Механизмы - ELCO_Слив: 0; ADSK_Расход воздуха приточный: 0 m3/s; ADSK_Расход жидкости: 0 m3/s; ELCO_Отвод домовых газов: 0 m3/s; ELCO_Расход газа: 0 m3/s; Классификация систем: Приточный воздух,Мощность,Не определено,Обратная жидкость,Приточная жидкость,Канализация,Отработанный воздух
Прочее - Код типа: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000: XXL EVO 1400; Семейство: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000: XXL EVO 1400; Семейство и типоразмер: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000: XXL EVO 1400; Тип: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000: XXL EVO 1400
Размеры - Смещение водяного соединителя: 0 mm; Объем: 5.16931 m3; Смещение фланца: 45 mm
Стадии - Стадия возведения: Стадия 1

# IfcEnergyConversionDevice: XXL EVO 1550, BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000:XXL EVO 1550:683214
In: Этаж 01
Type - PredefinedType: WATER; Material: Color RGB 120-120-120, Color RGB 216-216-216, Color RGB 181-181-181, Color RGB 255-255-240, Color RGB 100-100-100, Color RGB 049-049-049
Type - Видимость - Газ_Фланец: yes
Type - Графика - Зона обслуживания_Глубина_Задняя часть: 450 mm; Зона обслуживания_Глубина_Левая сторона: 800 mm; Зона обслуживания_Глубина_Лицевая часть: 1000 mm; Зона обслуживания_Глубина_Правая сторона: 450 mm; Привязка_Зона обслуживания_Задняя часть: 710 mm
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: ELCO; ADSK_Код изделия: 3581773; ADSK_Марка: TRIGON XXL EVO 1550; ADSK_Наименование: Водотрубный премиксный конденсационный котел TRIGON XXL EVO, 1467 кВт, максимальное давление 8 Бар; ELCO_Страна производства: Нидерланды
Type - Идентификация - ADSK_URL документации изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_URL страницы изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.pro/manufacturer/company/16987; BL_Email: support@ru.elco.net; BL_Разработано: support@bimlib.pro; URL: https://elco.net.ru/; Заголовок OmniClass: Hot Water Heat Generators; Изготовитель: ELCO Heating Solutions; Имя типа: XXL EVO 1550; Номер OmniClass: 23.75.10.11.14; Описание: Высокоэффективные водотрубные премиксные котлы TRIGON XXL с уникальной модулируемой водоохлаждаемой горелкой. TRIGON XXL EVO – высокоэффективные конденсационные котлы с эффективностью до 109,7 %
Type - Механизмы - Гидравлическое сопротивление при номинальном расходе ΔT=20: 128000 Pa; Давление воды макс: 800000 Pa; Давление воды мин: 150000 Pa; Максимальная рабочая температура: 90 kg/K/s3; Максимальная разница температур между подающей и обратной линией: 30 kg/K/s3; Номинальный расход при ΔT=20: 0.0175 m3/s; Объем воды: 0.157 m3
Type - Механизмы - Нагрузки - Минимальная тепловая мощность при 50⁄30 ⁰С: 463000 W; Минимальная тепловая мощность при 80⁄60 ⁰С: 417000 W; Номинальная тепловая мощность при 50⁄30 ⁰С: 1553000 W; Номинальная тепловая мощность при 80⁄60 ⁰С: 1467000 W; Номинальная тепловая нагрузка макс: 1499000 W; Номинальная тепловая нагрузка мин: 428000 W; Эффективность на макс при 50⁄30 ⁰С: 1.036; Эффективность на макс при 80⁄60 ⁰С: 0.978; Эффективность на мин при 50⁄30 ⁰С: 1.082; Эффективность на мин при 80⁄60 ⁰С: 0.974
Type - Механизмы - Расход - Максимальное давление газа: 10000 Pa; Максимальный расход газа: 0.044754 m3/s; Минимальное давление природного газа G20: 3500 Pa; Минимальное давление природного газа G25: 3500 Pa; Минимальное давление СУГ G31: 5000 Pa; Минимальный расход газа: 0.0127783 m3/s; Номинальное давление природного газа G20: 3500 Pa; Номинальное давление природного газа G25: 3500 Pa; Номинальное давление СУГ G31: 5000 Pa; Фактическая калорийность газа: 8000
Type - Прочее - Категория: Оборудование; Имя семейства: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000; Макс. температура дымовых газов при 80⁄60 oС: 69 kg/K/s3; Максимальный объемный расход конденсата: 97 Л/ч; Максимальный остаточный напор дымовых газов после котла: 150 Pa; Максимальный уровень CO: 4 мг⁄кВт∙ч; Максимальный уровень N⁰x: 37 мг⁄кВт∙ч; Массовый расход дымовых газов макс: 2439 кг/ч; Массовый расход дымовых газов мин: 741 кг/ч; Объемный расход дымовых газов макс: 0.640833 m3/s; Объемный расход дымовых газов мин: 0.188889 m3/s
Type - Размеры - Соединитель 1: yes; Соединитель 1 Длина: 0 mm; Соединитель 2: no; Горелка 1: no; Горелка 2: yes; Смещение ножек: 1524 mm; ADSK_Размер_Высота: 1575 mm; ADSK_Размер_Глубина: 3310 mm; ADSK_Размер_Ширина: 1570 mm; B1: 1375 mm; B2: 785 mm; B3: 195 mm; B4: 1360 mm; B5: 190 mm; B6: 1180 mm; D: 500 mm; G: 89 mm; H1: 1065 mm; H2: 615 mm; H3: 490 mm; H4: 435 mm; L1: 480 mm; L2: 1550 mm; L3: 350 mm; L4: 150 mm; L5: 710 mm; LW: 185 mm; W: 89 mm; Высота G: 435 mm; Высота W: 615 mm; Высота дымовых газов: 490 mm; Высота слива: 161 mm; Глубина блока: 2600 mm; Диаметр компенсатора: 300 mm; Длина 1_1: 512 mm; Длина 1_2: 679.5 mm; Длина 1_3: 679.5 mm; Длина 2_1: 512 mm; Длина 2_2: 968 mm; Длина 2_3: 1 mm; Длина 3_1: 2448 mm; Длина 3_2: 1 mm; Длина отрезка: 325 mm; Подключение воды: 80 mm; Подключение газа: 80 mm; Подключение дымохода: 500 mm; Подключение забора воздуха_для внешнего забора: 450 mm; Подключение слива конденсата: 40 mm; Радиус компенсатора: 152 mm; Служебный размер: 18 mm; Смещение: 94 mm; Смещение соединения воды: 1225 mm; Соединитель 2 Длина: 480 mm; Углубление: 10 mm; Ширина G: 190 mm; Ширина W: 1375 mm; Ширина дымовых газов: 350 mm; Ширина полки Горелки: 865.4 mm; Ширина слива: 105 mm
Type - Силы - Уровень звуковой мощности: 68.7 дБ(А)
Type - Текст - ADSK_Масса: 2100
Type - Электросети - Класс защиты от поражения электрическим током: IP00; Потребляемая котлом электрическая мощность макс: 2770 W; Потребляемая котлом электрическая мощность мин: 695 W; Предохранитель: 16 A; Частота: 50 Hz
Type - Электросети - Нагрузки - ADSK_Количество фаз: 1; ADSK_Напряжение: 400 V
Видимость - Зона обслуживания: no; Контрфланец: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 54
Механизмы - ELCO_Слив: 0; ADSK_Расход воздуха приточный: 0 m3/s; ADSK_Расход жидкости: 0 m3/s; ELCO_Отвод домовых газов: 0 m3/s; ELCO_Расход газа: 0 m3/s; Классификация систем: Приточный воздух,Мощность,Не определено,Обратная жидкость,Приточная жидкость,Канализация,Отработанный воздух
Прочее - Код типа: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000: XXL EVO 1550; Семейство: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000: XXL EVO 1550; Семейство и типоразмер: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000: XXL EVO 1550; Тип: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000: XXL EVO 1550
Размеры - Смещение водяного соединителя: 0 mm; Объем: 5.90668 m3; Смещение фланца: 45 mm
Стадии - Стадия возведения: Стадия 1

# IfcEnergyConversionDevice: XXL EVO 1700, BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000:XXL EVO 1700:683222
In: Этаж 01
Type - PredefinedType: WATER; Material: Color RGB 120-120-120, Color RGB 216-216-216, Color RGB 181-181-181, Color RGB 255-255-240, Color RGB 100-100-100, Color RGB 049-049-049
Type - Видимость - Газ_Фланец: yes
Type - Графика - Зона обслуживания_Глубина_Задняя часть: 450 mm; Зона обслуживания_Глубина_Левая сторона: 800 mm; Зона обслуживания_Глубина_Лицевая часть: 1000 mm; Зона обслуживания_Глубина_Правая сторона: 450 mm; Привязка_Зона обслуживания_Задняя часть: 710 mm
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: ELCO; ADSK_Код изделия: 3581774; ADSK_Марка: TRIGON XXL EVO 1700; ADSK_Наименование: Водотрубный премиксный конденсационный котел TRIGON XXL EVO, 1630 кВт, максимальное давление 8 Бар; ELCO_Страна производства: Нидерланды
Type - Идентификация - ADSK_URL документации изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_URL страницы изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.pro/manufacturer/company/16987; BL_Email: support@ru.elco.net; BL_Разработано: support@bimlib.pro; URL: https://elco.net.ru/; Заголовок OmniClass: Hot Water Heat Generators; Изготовитель: ELCO Heating Solutions; Имя типа: XXL EVO 1700; Номер OmniClass: 23.75.10.11.14; Описание: Высокоэффективные водотрубные премиксные котлы TRIGON XXL с уникальной модулируемой водоохлаждаемой горелкой. TRIGON XXL EVO – высокоэффективные конденсационные котлы с эффективностью до 109,7 %
Type - Механизмы - Гидравлическое сопротивление при номинальном расходе ΔT=20: 160000 Pa; Давление воды макс: 800000 Pa; Давление воды мин: 150000 Pa; Максимальная рабочая температура: 90 kg/K/s3; Максимальная разница температур между подающей и обратной линией: 30 kg/K/s3; Номинальный расход при ΔT=20: 0.0194444 m3/s; Объем воды: 0.166 m3
Type - Механизмы - Нагрузки - Минимальная тепловая мощность при 50⁄30 ⁰С: 515000 W; Минимальная тепловая мощность при 80⁄60 ⁰С: 464000 W; Номинальная тепловая мощность при 50⁄30 ⁰С: 1726000 W; Номинальная тепловая мощность при 80⁄60 ⁰С: 1630000 W; Номинальная тепловая нагрузка макс: 1666000 W; Номинальная тепловая нагрузка мин: 476000 W; Эффективность на макс при 50⁄30 ⁰С: 1.036; Эффективность на макс при 80⁄60 ⁰С: 0.978; Эффективность на мин при 50⁄30 ⁰С: 1.082; Эффективность на мин при 80⁄60 ⁰С: 0.974
Type - Механизмы - Расход - Максимальное давление газа: 10000 Pa; Максимальный расход газа: 0.0497399 m3/s; Минимальное давление природного газа G20: 3500 Pa; Минимальное давление природного газа G25: 3500 Pa; Минимальное давление СУГ G31: 5000 Pa; Минимальный расход газа: 0.0142114 m3/s; Номинальное давление природного газа G20: 3500 Pa; Номинальное давление природного газа G25: 3500 Pa; Номинальное давление СУГ G31: 5000 Pa; Фактическая калорийность газа: 8000
Type - Прочее - Категория: Оборудование; Имя семейства: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000; Макс. температура дымовых газов при 80⁄60 oС: 69 kg/K/s3; Максимальный объемный расход конденсата: 108 Л/ч; Максимальный остаточный напор дымовых газов после котла: 150 Pa; Максимальный уровень CO: 4 мг⁄кВт∙ч; Максимальный уровень N⁰x: 37 мг⁄кВт∙ч; Массовый расход дымовых газов макс: 2711 кг/ч; Массовый расход дымовых газов мин: 824 кг/ч; Объемный расход дымовых газов макс: 0.7125 m3/s; Объемный расход дымовых газов мин: 0.21 m3/s
Type - Размеры - Соединитель 1: yes; Соединитель 1 Длина: 0 mm; Соединитель 2: no; Горелка 1: no; Горелка 2: yes; Смещение ножек: 1524 mm; ADSK_Размер_Высота: 1575 mm; ADSK_Размер_Глубина: 3310 mm; ADSK_Размер_Ширина: 1570 mm; B1: 1425 mm; B2: 785 mm; B3: 145 mm; B4: 1360 mm; B5: 140 mm; B6: 1280 mm; D: 500 mm; G: 89 mm; H1: 1065 mm; H2: 615 mm; H3: 490 mm; H4: 435 mm; L1: 480 mm; L2: 1550 mm; L3: 350 mm; L4: 150 mm; L5: 710 mm; LW: 185 mm; W: 89 mm; Высота G: 435 mm; Высота W: 615 mm; Высота дымовых газов: 490 mm; Высота слива: 161 mm; Глубина блока: 2600 mm; Диаметр компенсатора: 300 mm; Длина 1_1: 512 mm; Длина 1_2: 679.5 mm; Длина 1_3: 679.5 mm; Длина 2_1: 512 mm; Длина 2_2: 968 mm; Длина 2_3: 1 mm; Длина 3_1: 2448 mm; Длина 3_2: 1 mm; Длина отрезка: 325 mm; Подключение воды: 80 mm; Подключение газа: 80 mm; Подключение дымохода: 500 mm; Подключение забора воздуха_для внешнего забора: 450 mm; Подключение слива конденсата: 40 mm; Радиус компенсатора: 152 mm; Служебный размер: 18 mm; Смещение: 94 mm; Смещение соединения воды: 1225 mm; Соединитель 2 Длина: 480 mm; Углубление: 10 mm; Ширина G: 140 mm; Ширина W: 1425 mm; Ширина дымовых газов: 350 mm; Ширина полки Горелки: 945.4 mm; Ширина слива: 105 mm
Type - Силы - Уровень звуковой мощности: 68.7 дБ(А)
Type - Текст - ADSK_Масса: 2201
Type - Электросети - Класс защиты от поражения электрическим током: IP00; Потребляемая котлом электрическая мощность макс: 2770 W; Потребляемая котлом электрическая мощность мин: 695 W; Предохранитель: 16 A; Частота: 50 Hz
Type - Электросети - Нагрузки - ADSK_Количество фаз: 1; ADSK_Напряжение: 400 V
Видимость - Зона обслуживания: no; Контрфланец: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 55
Механизмы - ELCO_Слив: 0; ADSK_Расход воздуха приточный: 0 m3/s; ADSK_Расход жидкости: 0 m3/s; ELCO_Отвод домовых газов: 0 m3/s; ELCO_Расход газа: 0 m3/s; Классификация систем: Приточный воздух,Мощность,Не определено,Обратная жидкость,Приточная жидкость,Канализация,Отработанный воздух
Прочее - Код типа: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000: XXL EVO 1700; Семейство: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000: XXL EVO 1700; Семейство и типоразмер: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000: XXL EVO 1700; Тип: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000: XXL EVO 1700
Размеры - Смещение водяного соединителя: 0 mm; Объем: 5.91671 m3; Смещение фланца: 45 mm
Стадии - Стадия возведения: Стадия 1

# IfcEnergyConversionDevice: XXL EVO 2000, BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000:XXL EVO 2000:683232
In: Этаж 01
Type - PredefinedType: WATER; Material: Color RGB 120-120-120, Color RGB 216-216-216, Color RGB 181-181-181, Color RGB 255-255-240, Color RGB 100-100-100, Color RGB 049-049-049
Type - Видимость - Газ_Фланец: yes
Type - Графика - Зона обслуживания_Глубина_Задняя часть: 450 mm; Зона обслуживания_Глубина_Левая сторона: 800 mm; Зона обслуживания_Глубина_Лицевая часть: 1000 mm; Зона обслуживания_Глубина_Правая сторона: 450 mm; Привязка_Зона обслуживания_Задняя часть: 710 mm
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: ELCO; ADSK_Код изделия: 3581775; ADSK_Марка: TRIGON XXL EVO 2000; ADSK_Наименование: Водотрубный премиксный конденсационный котел TRIGON XXL EVO, 1953 кВт, максимальное давление 8 Бар; ELCO_Страна производства: Нидерланды
Type - Идентификация - ADSK_URL документации изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_URL страницы изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.pro/manufacturer/company/16987; BL_Email: support@ru.elco.net; BL_Разработано: support@bimlib.pro; URL: https://elco.net.ru/; Заголовок OmniClass: Hot Water Heat Generators; Изготовитель: ELCO Heating Solutions; Имя типа: XXL EVO 2000; Номер OmniClass: 23.75.10.11.14; Описание: Высокоэффективные водотрубные премиксные котлы TRIGON XXL с уникальной модулируемой водоохлаждаемой горелкой. TRIGON XXL EVO – высокоэффективные конденсационные котлы с эффективностью до 109,7 %
Type - Механизмы - Гидравлическое сопротивление при номинальном расходе ΔT=20: 216000 Pa; Давление воды макс: 800000 Pa; Давление воды мин: 150000 Pa; Максимальная рабочая температура: 90 kg/K/s3; Максимальная разница температур между подающей и обратной линией: 30 kg/K/s3; Номинальный расход при ΔT=20: 0.0233333 m3/s; Объем воды: 0.209 m3
Type - Механизмы - Нагрузки - Минимальная тепловая мощность при 50⁄30 ⁰С: 541000 W; Минимальная тепловая мощность при 80⁄60 ⁰С: 487000 W; Номинальная тепловая мощность при 50⁄30 ⁰С: 2069000 W; Номинальная тепловая мощность при 80⁄60 ⁰С: 1953000 W; Номинальная тепловая нагрузка макс: 2000000 W; Номинальная тепловая нагрузка мин: 500000 W; Эффективность на макс при 50⁄30 ⁰С: 1.035; Эффективность на макс при 80⁄60 ⁰С: 0.977; Эффективность на мин при 50⁄30 ⁰С: 1.082; Эффективность на мин при 80⁄60 ⁰С: 0.974
Type - Механизмы - Расход - Максимальное давление газа: 10000 Pa; Максимальный расход газа: 0.0597118 m3/s; Минимальное давление природного газа G20: 5000 Pa; Минимальное давление природного газа G25: 5000 Pa; Минимальное давление СУГ G31: 5000 Pa; Минимальный расход газа: 0.014928 m3/s; Номинальное давление природного газа G20: 5000 Pa; Номинальное давление природного газа G25: 5000 Pa; Номинальное давление СУГ G31: 5000 Pa; Фактическая калорийность газа: 8000
Type - Прочее - Категория: Оборудование; Имя семейства: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000; Макс. температура дымовых газов при 80⁄60 oС: 73 kg/K/s3; Максимальный объемный расход конденсата: 130 Л/ч; Максимальный остаточный напор дымовых газов после котла: 150 Pa; Максимальный уровень CO: 7 мг⁄кВт∙ч; Максимальный уровень N⁰x: 32 мг⁄кВт∙ч; Массовый расход дымовых газов макс: 3249 кг/ч; Массовый расход дымовых газов мин: 865 кг/ч; Объемный расход дымовых газов макс: 0.865278 m3/s; Объемный расход дымовых газов мин: 0.220833 m3/s
Type - Размеры - Соединитель 1: yes; Соединитель 1 Длина: 0 mm; Соединитель 2: no; Горелка 1: no; Горелка 2: yes; Смещение ножек: 1524 mm; ADSK_Размер_Высота: 1665 mm; ADSK_Размер_Глубина: 3310 mm; ADSK_Размер_Ширина: 1570 mm; B1: 1430 mm; B2: 785 mm; B3: 1425 mm; B4: 1146 mm; B5: 145 mm; B6: 5 mm; D: 500 mm; G: 89 mm; H1: 1225 mm; H2: 395 mm; H3: 505 mm; H4: 435 mm; L1: 480 mm; L2: 1550 mm; L3: 350 mm; L4: 165 mm; L5: 710 mm; LW: 185 mm; W: 89 mm; Высота G: 435 mm; Высота W: 395 mm; Высота дымовых газов: 505 mm; Высота слива: 161 mm; Глубина блока: 2600 mm; Диаметр компенсатора: 300 mm; Длина 1_1: 512 mm; Длина 1_2: 679.5 mm; Длина 1_3: 679.5 mm; Длина 2_1: 512 mm; Длина 2_2: 968 mm; Длина 2_3: 1 mm; Длина 3_1: 2448 mm; Длина 3_2: 1 mm; Длина отрезка: 325 mm; Подключение воды: 80 mm; Подключение газа: 80 mm; Подключение дымохода: 500 mm; Подключение забора воздуха_для внешнего забора: 450 mm; Подключение слива конденсата: 40 mm; Радиус компенсатора: 152 mm; Служебный размер: 18 mm; Смещение: 94 mm; Смещение соединения воды: 1225 mm; Соединитель 2 Длина: 480 mm; Углубление: 10 mm; Ширина G: 145 mm; Ширина W: 1430 mm; Ширина дымовых газов: 350 mm; Ширина полки Горелки: 945.4 mm; Ширина слива: 105 mm
Type - Силы - Уровень звуковой мощности: 72,7 дБ(А)
Type - Текст - ADSK_Масса: 2500
Type - Электросети - Класс защиты от поражения электрическим током: IP00; Потребляемая котлом электрическая мощность макс: 2770 W; Потребляемая котлом электрическая мощность мин: 695 W; Предохранитель: 16 A; Частота: 50 Hz
Type - Электросети - Нагрузки - ADSK_Количество фаз: 1; ADSK_Напряжение: 400 V
Видимость - Зона обслуживания: no; Контрфланец: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 56
Механизмы - ELCO_Слив: 0; ADSK_Расход воздуха приточный: 0 m3/s; ADSK_Расход жидкости: 0 m3/s; ELCO_Отвод домовых газов: 0 m3/s; ELCO_Расход газа: 0 m3/s; Классификация систем: Приточный воздух,Мощность,Не определено,Обратная жидкость,Приточная жидкость,Канализация,Отработанный воздух
Прочее - Код типа: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000: XXL EVO 2000; Семейство: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000: XXL EVO 2000; Семейство и типоразмер: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000: XXL EVO 2000; Тип: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000: XXL EVO 2000
Размеры - Смещение водяного соединителя: 0 mm; Объем: 6.27678 m3; Смещение фланца: 45 mm
Стадии - Стадия возведения: Стадия 1

# IfcEnergyConversionDevice: XXL EVO 700, BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000:XXL EVO 700:667764
In: Этаж 01
Type - PredefinedType: WATER; Material: Color RGB 120-120-120, Color RGB 216-216-216, Color RGB 181-181-181, Color RGB 255-255-240, Color RGB 100-100-100, Color RGB 049-049-049
Type - Видимость - Газ_Фланец: no
Type - Графика - Зона обслуживания_Глубина_Задняя часть: 450 mm; Зона обслуживания_Глубина_Левая сторона: 800 mm; Зона обслуживания_Глубина_Лицевая часть: 1000 mm; Зона обслуживания_Глубина_Правая сторона: 450 mm; Привязка_Зона обслуживания_Задняя часть: 550 mm
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: ELCO; ADSK_Код изделия: 3581766; ADSK_Марка: TRIGON XXL EVO 700; ADSK_Наименование: Водотрубный премиксный конденсационный котел TRIGON XXL EVO, 639 кВт, максимальное давление 8 Бар; ELCO_Страна производства: Нидерланды
Type - Идентификация - ADSK_URL документации изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_URL страницы изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.pro/manufacturer/company/16987; BL_Email: support@ru.elco.net; BL_Разработано: support@bimlib.pro; URL: https://elco.net.ru/; Заголовок OmniClass: Hot Water Heat Generators; Изготовитель: ELCO Heating Solutions; Имя типа: XXL EVO 700; Номер OmniClass: 23.75.10.11.14; Описание: Высокоэффективные водотрубные премиксные котлы TRIGON XXL с уникальной модулируемой водоохлаждаемой горелкой. TRIGON XXL EVO – высокоэффективные конденсационные котлы с эффективностью до 109,7 %
Type - Механизмы - Гидравлическое сопротивление при номинальном расходе ΔT=20: 74000 Pa; Давление воды макс: 800000 Pa; Давление воды мин: 150000 Pa; Максимальная рабочая температура: 90 kg/K/s3; Максимальная разница температур между подающей и обратной линией: 30 kg/K/s3; Номинальный расход при ΔT=20: 0.0075 m3/s; Объем воды: 0.073 m3
Type - Механизмы - Нагрузки - Минимальная тепловая мощность при 50⁄30 ⁰С: 202000 W; Минимальная тепловая мощность при 80⁄60 ⁰С: 182000 W; Номинальная тепловая мощность при 50⁄30 ⁰С: 676000 W; Номинальная тепловая мощность при 80⁄60 ⁰С: 639000 W; Номинальная тепловая нагрузка макс: 653000 W; Номинальная тепловая нагрузка мин: 187000 W; Эффективность на макс при 50⁄30 ⁰С: 1.036; Эффективность на макс при 80⁄60 ⁰С: 0.978; Эффективность на мин при 50⁄30 ⁰С: 1.082; Эффективность на мин при 80⁄60 ⁰С: 0.974
Type - Механизмы - Расход - Максимальное давление газа: 10000 Pa; Максимальный расход газа: 0.0194959 m3/s; Минимальное давление природного газа G20: 1700 Pa; Минимальное давление природного газа G25: 2000 Pa; Минимальное давление СУГ G31: 3000 Pa; Минимальный расход газа: 0.00558305 m3/s; Номинальное давление природного газа G20: 2000 Pa; Номинальное давление природного газа G25: 2500 Pa; Номинальное давление СУГ G31: 3000 Pa; Фактическая калорийность газа: 8000
Type - Прочее - Категория: Оборудование; Имя семейства: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000; Макс. температура дымовых газов при 80⁄60 oС: 69 kg/K/s3; Максимальный объемный расход конденсата: 42,4 Л/ч; Максимальный остаточный напор дымовых газов после котла: 150 Pa; Максимальный уровень CO: 4 мг⁄кВт∙ч; Максимальный уровень N⁰x: 37 мг⁄кВт∙ч; Массовый расход дымовых газов макс: 1062 кг/ч; Массовый расход дымовых газов мин: 324 кг/ч; Объемный расход дымовых газов макс: 0.279167 m3/s; Объемный расход дымовых газов мин: 0.0825 m3/s
Type - Размеры - ADSK_Размер_Высота: 1555 mm; ADSK_Размер_Глубина: 2185 mm; ADSK_Размер_Ширина: 1370 mm; B1: 1235 mm; B2: 685 mm; B3: 135 mm; B4: 1160 mm; B5: 100 mm; B6: 1100 mm; D: 300 mm; G: 60 mm; H1: 1110 mm; H2: 660 mm; H3: 530 mm; H4: 460 mm; L1: 475 mm; L2: 660 mm; L3: 260 mm; L4: 110 mm; L5: 550 mm; LW: 185 mm; W: 76 mm; Высота G: 460 mm; Высота W: 660 mm; Высота дымовых газов: 530 mm; Высота слива: 272 mm; Глубина блока: 1710 mm; Горелка 1: yes; Горелка 2: no; Диаметр компенсатора: 189 mm; Длина 1_1: 512 mm; Длина 1_2: 679.5 mm; Длина 1_3: 1 mm; Длина 2_1: 1558 mm; Длина 2_2: 1 mm; Длина 2_3: 1 mm; Длина 3_1: 1558 mm; Длина 3_2: 1 mm; Длина отрезка: 325 mm; Подключение воды: 65 mm; Подключение газа: 50 mm; Подключение дымохода: 300 mm; Подключение забора воздуха_для внешнего забора: 250 mm; Подключение слива конденсата: 40 mm; Радиус компенсатора: 96.5 mm; Служебный размер: 18 mm; Смещение: 94 mm; Смещение ножек: 1324 mm; Смещение соединения воды: 1225 mm; Соединитель 1: yes; Соединитель 1 Длина: 0 mm; Соединитель 2: no; Соединитель 2 Длина: 475 mm; Углубление: 10 mm; Ширина G: 100 mm; Ширина W: 1235 mm; Ширина дымовых газов: 260 mm; Ширина полки Горелки: 945.4 mm; Ширина слива: 645 mm
Type - Силы - Уровень звуковой мощности: 68,7 дБ(А)
Type - Текст - ADSK_Масса: 2500
Type - Электросети - Класс защиты от поражения электрическим током: IP00; Потребляемая котлом электрическая мощность макс: 900 W; Потребляемая котлом электрическая мощность мин: 225 W; Предохранитель: 16 A; Частота: 50 Hz
Type - Электросети - Нагрузки - ADSK_Количество фаз: 1; ADSK_Напряжение: 400 V
Видимость - Зона обслуживания: no; Контрфланец: no
Зависимости - Основа: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Идентификация - Марка: 47
Механизмы - ADSK_Расход воздуха приточный: 0 m3/s; ADSK_Расход жидкости: 0 m3/s; ELCO_Отвод домовых газов: 0 m3/s; ELCO_Расход газа: 0 m3/s; ELCO_Слив: 0; Классификация систем: Приточный воздух,Мощность,Не определено,Обратная жидкость,Приточная жидкость,Канализация,Отработанный воздух
Прочее - Код типа: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000: XXL EVO 700; Семейство: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000: XXL EVO 700; Семейство и типоразмер: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000: XXL EVO 700; Тип: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000: XXL EVO 700
Размеры - Объем: 3.36852 m3; Смещение водяного соединителя: 0 mm; Смещение фланца: 45 mm
Стадии - Стадия возведения: Стадия 1

# IfcEnergyConversionDevice: XXL EVO 800, BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000:XXL EVO 800:683044
In: Этаж 01
Type - PredefinedType: WATER; Material: Color RGB 120-120-120, Color RGB 216-216-216, Color RGB 181-181-181, Color RGB 255-255-240, Color RGB 100-100-100, Color RGB 049-049-049
Type - Видимость - Газ_Фланец: no
Type - Графика - Зона обслуживания_Глубина_Задняя часть: 450 mm; Зона обслуживания_Глубина_Левая сторона: 800 mm; Зона обслуживания_Глубина_Лицевая часть: 1000 mm; Зона обслуживания_Глубина_Правая сторона: 450 mm; Привязка_Зона обслуживания_Задняя часть: 550 mm
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: ELCO; ADSK_Код изделия: 3581767; ADSK_Марка: TRIGON XXL EVO 800; ADSK_Наименование: Водотрубный премиксный конденсационный котел TRIGON XXL EVO, 747 кВт, максимальное давление 8 Бар; ELCO_Страна производства: Нидерланды
Type - Идентификация - ADSK_URL документации изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_URL страницы изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.pro/manufacturer/company/16987; BL_Email: support@ru.elco.net; BL_Разработано: support@bimlib.pro; URL: https://elco.net.ru/; Заголовок OmniClass: Hot Water Heat Generators; Изготовитель: ELCO Heating Solutions; Имя типа: XXL EVO 800; Номер OmniClass: 23.75.10.11.14; Описание: Высокоэффективные водотрубные премиксные котлы TRIGON XXL с уникальной модулируемой водоохлаждаемой горелкой. TRIGON XXL EVO – высокоэффективные конденсационные котлы с эффективностью до 109,7 %
Type - Механизмы - Гидравлическое сопротивление при номинальном расходе ΔT=20: 40000 Pa; Давление воды макс: 800000 Pa; Давление воды мин: 150000 Pa; Максимальная рабочая температура: 90 kg/K/s3; Максимальная разница температур между подающей и обратной линией: 30 kg/K/s3; Номинальный расход при ΔT=20: 0.00888889 m3/s; Объем воды: 0.097 m3
Type - Механизмы - Нагрузки - Минимальная тепловая мощность при 50⁄30 ⁰С: 236000 W; Минимальная тепловая мощность при 80⁄60 ⁰С: 212000 W; Номинальная тепловая мощность при 50⁄30 ⁰С: 791000 W; Номинальная тепловая мощность при 80⁄60 ⁰С: 747000 W; Номинальная тепловая нагрузка макс: 764000 W; Номинальная тепловая нагрузка мин: 218000 W; Эффективность на макс при 50⁄30 ⁰С: 1.036; Эффективность на макс при 80⁄60 ⁰С: 0.978; Эффективность на мин при 50⁄30 ⁰С: 1.082; Эффективность на мин при 80⁄60 ⁰С: 0.974
Type - Механизмы - Расход - Максимальное давление газа: 10000 Pa; Максимальный расход газа: 0.0228099 m3/s; Минимальное давление природного газа G20: 1700 Pa; Минимальное давление природного газа G25: 2000 Pa; Минимальное давление СУГ G31: 3000 Pa; Минимальный расход газа: 0.00650859 m3/s; Номинальное давление природного газа G20: 2000 Pa; Номинальное давление природного газа G25: 2500 Pa; Номинальное давление СУГ G31: 3000 Pa; Фактическая калорийность газа: 8000
Type - Прочее - Категория: Оборудование; Имя семейства: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000; Макс. температура дымовых газов при 80⁄60 oС: 69 kg/K/s3; Максимальный объемный расход конденсата: 49.6 Л/ч; Максимальный остаточный напор дымовых газов после котла: 150 Pa; Максимальный уровень CO: 4 мг⁄кВт∙ч; Максимальный уровень N⁰x: 37 мг⁄кВт∙ч; Массовый расход дымовых газов макс: 1243 кг/ч; Массовый расход дымовых газов мин: 377 кг/ч; Объемный расход дымовых газов макс: 0.326667 m3/s; Объемный расход дымовых газов мин: 0.0961111 m3/s
Type - Размеры - Горелка 1: yes; Горелка 2: no; Соединитель 1: yes; Соединитель 1 Длина: 0 mm; Соединитель 2: no; ADSK_Размер_Высота: 1555 mm; ADSK_Размер_Глубина: 2565 mm; ADSK_Размер_Ширина: 1170 mm; B1: 1025 mm; B2: 585 mm; B3: 145 mm; B4: 960 mm; B5: 150 mm; B6: 880 mm; D: 350 mm; G: 60 mm; H1: 1110 mm; H2: 660 mm; H3: 530 mm; H4: 460 mm; L1: 480 mm; L2: 1030 mm; L3: 260 mm; L4: 110 mm; L5: 550 mm; LW: 185 mm; W: 89 mm; Высота G: 460 mm; Высота W: 660 mm; Высота дымовых газов: 530 mm; Высота слива: 272 mm; Глубина блока: 2085 mm; Диаметр компенсатора: 200 mm; Длина 1_1: 678.5 mm; Длина 1_2: 674 mm; Длина 1_3: 1 mm; Длина 2_1: 968 mm; Длина 2_2: 1 mm; Длина 2_3: 1 mm; Длина 3_1: 1933 mm; Длина 3_2: 1 mm; Длина отрезка: 325 mm; Подключение воды: 80 mm; Подключение газа: 50 mm; Подключение дымохода: 350 mm; Подключение забора воздуха_для внешнего забора: 355 mm; Подключение слива конденсата: 40 mm; Радиус компенсатора: 102 mm; Служебный размер: 18 mm; Смещение: 94 mm; Смещение ножек: 1124 mm; Смещение соединения воды: 1225 mm; Соединитель 2 Длина: 480 mm; Углубление: 10 mm; Ширина G: 150 mm; Ширина W: 1025 mm; Ширина дымовых газов: 260 mm; Ширина полки Горелки: 616 mm; Ширина слива: 645 mm
Type - Силы - Уровень звуковой мощности: 68.7 дБ(А)
Type - Текст - ADSK_Масса: 1328
Type - Электросети - Класс защиты от поражения электрическим током: IP00; Потребляемая котлом электрическая мощность макс: 900 W; Потребляемая котлом электрическая мощность мин: 320 W; Предохранитель: 16 A; Частота: 50 Hz
Type - Электросети - Нагрузки - ADSK_Количество фаз: 1; ADSK_Напряжение: 400 V
Видимость - Зона обслуживания: no; Контрфланец: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 48
Механизмы - ELCO_Слив: 0; ADSK_Расход воздуха приточный: 0 m3/s; ADSK_Расход жидкости: 0 m3/s; ELCO_Отвод домовых газов: 0 m3/s; ELCO_Расход газа: 0 m3/s; Классификация систем: Приточный воздух,Мощность,Не определено,Обратная жидкость,Приточная жидкость,Канализация,Отработанный воздух
Прочее - Код типа: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000: XXL EVO 800; Семейство: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000: XXL EVO 800; Семейство и типоразмер: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000: XXL EVO 800; Тип: BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000: XXL EVO 800
Размеры - Смещение водяного соединителя: 0 mm; Объем: 3.49254 m3; Смещение фланца: 45 mm
Стадии - Стадия возведения: Стадия 1

# IfcEnergyConversionDevice: XXL EVO 900, BIMLIB_Котел_Конденсационный_Премиксный_ELCO_TrigonXXL_EVO_700-2000:XXL EVO 900:683168
In: Этаж 01
Type - PredefinedType: WATER; Material: Color RGB 120-120-120, Color RGB 216-216-216, Color RGB 181-181-181, Color RGB 255-255-240, Color RGB 100-100-100, Color RGB 049-049-049
Type - Видимость - Газ_Фланец: no
Type - Графика - Зона обслуживания_Глубина_Задняя часть: 450 mm; Зона обслуживания_Глубина_Левая сторона: 800 mm; Зона обслуживания_Глубина_Лицевая часть: 1000 mm; Зона обслуживания_Глубина_Правая сторона: 450 mm; Привязка_Зона обслуживания_Задняя часть: 550 mm
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: ELCO; ADSK_Код изделия: 3581768; ADSK_Марка: TRIGON XXL EVO 900; ADSK_Наименование: Водотрубный премиксный конденсационный котел TRIGON XXL EVO, 846 кВт, максимальное давление 8 Бар; ELCO_Страна производства: Нидерланды
Type - Идентификация - ADSK_URL документации изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_URL страницы изделия: https://elco.net.ru/products/gas/trigonxxl/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.pro/manufacturer/company/16987; BL_Email: support@ru.elco.net; BL_Разработано: support@bimlib.pro; URL: https://elco.net.ru/; Заголовок OmniClass: Hot Water Heat Generators; Изготовитель: ELCO Heating Solutions; Имя типа: XXL EVO 900; Номер OmniClass: 23.75.10.11.14; Описание: Высокоэффективные водотрубные премиксные котлы TRIGON XXL с уникальной модулируемой водоохлаждаемой горелкой. TRIGON XXL EVO – высокоэффективные конденсационные котлы с эффективностью до 109,7 %
Type - Механизмы - Гидравлическое сопротивление при номинальном расходе ΔT=20: 55000 Pa; Давление воды макс: 800000 Pa; Давление воды мин: 150000 Pa; Максимальная рабочая температура: 90 kg/K/s3; Максимальная разница температур между подающей и обратной линией: 30 kg/K/s3; Номинальный расход при ΔT=20: 0.01 m3/s; Объем воды: 0.104 m3
Type - Механизмы - Нагрузки - Минимальная тепловая мощность при 50⁄30 ⁰С: 267000 W; Минимальная тепловая мощность при 80⁄60 ⁰С: 241000 W; Номинальная тепловая мощность при 50⁄30 ⁰С: 896000 W; Номинальная тепловая мощность при 80⁄60 ⁰С: 846000 W; Номинальная тепловая нагрузка макс: 865000 W; Номинальная тепловая нагрузка мин: 247000 W; Эффективность на макс при 50⁄30 ⁰С: 1.036; Эффективность на макс при 80⁄60 ⁰С: 0.978; Эффективность на мин при 50⁄30 ⁰С: 1.082; Эффективность на мин при 80⁄60 ⁰С: 0.974
Type - Механизмы - Расход - Максимальное давление газа: 10000 Pa; Максимальный расход газа: 0.0258254 m3/s; Минимальное давление природного газа G20: 1700 Pa; Минимальное давление природного газа G25: 2000 Pa; Минимальное давление СУГ G31: 3000 Pa; Минимальный расход газа: 0.00737441 m3/s; Номинальное давление природного газа G20: 2000 Pa; Номинальное давление природного газа G25: 2500 Pa; Номинальное давление СУГ G31: 3000 Pa; Фактическая калорийность газа: 8000
